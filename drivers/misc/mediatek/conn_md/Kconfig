## drivers/misc/mediatek/conn_md/Kconfig
```kconfig
config MTK_CONN_MD
  bool CONFIG_MTK_CONN_MD
  default n
  help
    CONFIG_MTK_CONN_MD
```
